# Keil uVision project BH-F103.uvprojx, settings and files
target Template-REG (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template-REG +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c misc: --no-multibyte-chars
  c include: ..\..\STM32\STM32class\18-EXTI\Libraries\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s main.c
